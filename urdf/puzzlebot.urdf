Commit message: Updated World and Launch files

File: urdf/puzzlebot.urdf (robot description, URDF)
Before this commit: robot Puzzlebot Jetson-Lidar, 4 links, 3 joints
Joints:
- joint chassis_joint_wL: type continuous -> fixed
- joint chassis_joint_wR: type continuous -> fixed
